# Keil uVision project ble_app_BMD200EVAL_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=1 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_CUSTOM SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  c include: C:\Keil_v5\ARM\Pack\NordicSemiconductor\nRF_Examples\8.1.0\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0xf000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Application
    ../../../: main.c ble_dis.c pwm_rgb.c ble_bmdeval.c bmd_adc.c MMA8652.c I2Cdrv.c bmd_accel.c app_gpiote.c version.h
  group Documentation
    ../../../: Abstract.txt license.txt dox_ext.h
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.1.0, Board Support:bsp 8.1.0, Device:Startup 7.2.1, nRF_BLE:BLE_Modules:ble_advdata 3.0.0, nRF_BLE:BLE_Modules:ble_advertising 3.0.0, nRF_BLE:BLE_Modules:ble_common 3.0.0, nRF_BLE:BLE_Modules:ble_conn_params 3.0.0, nRF_BLE:BLE_Modules:ble_service_common 3.0.0, nRF_Drivers:app_uart 3.0.0, nRF_Drivers:nrf_adc 3.0.0, nRF_Drivers:nrf_delay 3.0.0, nRF_Drivers:nrf_drv_common 3.0.0, nRF_Drivers:nrf_drv_gpiote 3.0.0, nRF_Drivers:nrf_error 3.0.0, nRF_Drivers:nrf_gpio 3.0.0, nRF_Drivers:nrf_gpiote 3.0.0, nRF_Drivers:pstorage 3.0.0, nRF_Drivers:twi_master 3.0.0, nRF_Libraries:app_button 3.0.0, nRF_Libraries:app_error 3.0.0, nRF_Libraries:app_scheduler 3.0.0, nRF_Libraries:app_timer 3.0.0, nRF_Libraries:app_timer_with_app_scheduler 3.0.0, nRF_Libraries:app_trace 3.0.0, nRF_Libraries:app_util 3.0.0, nRF_Libraries:nrf_assert 3.0.0, nRF_Libraries:retarget 3.0.0, nRF_SoftDevice:Internal:sd_common 1.1.3, nRF_SoftDevice:Internal:softdevice_present 1.1.3, nRF_SoftDevice:s110 8.0.0, nRF_SoftDevice:s110_hex 8.0.0, nRF_SoftDevice:softdevice_hex 1.1.3
