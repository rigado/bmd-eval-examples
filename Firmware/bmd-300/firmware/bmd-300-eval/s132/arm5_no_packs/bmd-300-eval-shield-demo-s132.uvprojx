# Keil uVision project bmd-300-eval-shield-demo-s132.uvprojx, settings and files
target bmd-300-demo-shield-release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_GPIO_AS_PINRESET USE_INTERNAL_RC __HEAP_SIZE=0
  c include: ..\..\..\config\ble_app_template_s132_pca10040;..\..\..\config;..\..\..\..\nrf5_sdk\components\ble\ble_advertising;..\..\..\..\nrf5_sdk\components\ble\common;..\..\..\..\nrf5_sdk\components\ble\device_manager;..\..\..\..\nrf5_sdk\components\drivers_nrf\common;..\..\..\..\nrf5_sdk\components\drivers_nrf\config;..\..\..\..\nrf5_sdk\components\drivers_nrf\delay;..\..\..\..\nrf5_sdk\components\drivers_nrf\gpiote;..\..\..\..\nrf5_sdk\components\drivers_nrf\hal;..\..\..\..\nrf5_sdk\components\drivers_nrf\pstorage;..\..\..\..\nrf5_sdk\components\drivers_nrf\uart;..\..\..\..\nrf5_sdk\components\libraries\button;..\..\..\..\nrf5_sdk\components\libraries\experimental_section_vars;..\..\..\..\nrf5_sdk\components\libraries\fstorage;..\..\..\..\nrf5_sdk\components\libraries\fstorage\config;..\..\..\..\nrf5_sdk\components\libraries\sensorsim;..\..\..\..\nrf5_sdk\components\libraries\timer;..\..\..\..\nrf5_sdk\components\libraries\trace;..\..\..\..\nrf5_sdk\components\libraries\uart;..\..\..\..\nrf5_sdk\components\libraries\util;..\..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler;..\..\..\..\nrf5_sdk\components\softdevice\s132\headers;..\..\..\..\nrf5_sdk\components\softdevice\s132\headers\nrf52;..\..\..\..\nrf5_sdk\components\toolchain;..\..\..\..\nrf5_sdk\examples\bsp;..\..\..\..\nrf5_sdk\external\segger_rtt;..\..\..\..\nrf5_sdk\components\libraries\twi;..\..\..\..\nrf5_sdk\components\drivers_nrf\twi_master;..\..\..\..\unity;..\..\..\..\firmware;..\..\..\..\nrf5_sdk\components\drivers_nrf\pwm;..\..\..\..\nrf5_sdk\components\drivers_nrf\saadc;..\..\..\..\nrf5_sdk\components\ble\ble_services\ble_dis
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group Application
    ../../../: ble_bmdeval.c ble_bmdeval_handler.c bmd_accel.c bmd_adc.c bmd_button.c bmd_pwm_rgb_led.c bmd_300_demo_shield_init.c main.c
  group Board Support
    ../../../../nrf5_sdk/examples/bsp/: bsp.c bsp_btn_ble.c
  group Drivers
    ../../../: MMA8652.c simple_uart.c
  group Libraries
    ../../../../unity/: unity.c unity_fixture.c
  group nRF_BLE
    ../../../../nrf5_sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../nrf5_sdk/components/ble/ble_advertising/: ble_advertising.c
    ../../../../nrf5_sdk/components/ble/device_manager/: device_manager_peripheral.c
    ../../../../nrf5_sdk/components/ble/ble_services/ble_dis/: ble_dis.c
  group nRF_Drivers
    ../../../../nrf5_sdk/components/libraries/uart/: app_uart.c
    ../../../../nrf5_sdk/components/drivers_nrf/delay/: nrf_delay.c
    ../../../../nrf5_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../nrf5_sdk/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../nrf5_sdk/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../nrf5_sdk/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../nrf5_sdk/components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../../../../nrf5_sdk/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../nrf5_sdk/components/drivers_nrf/hal/: nrf_saadc.c
    ../../../../nrf5_sdk/components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../nrf5_sdk/components/libraries/button/: app_button.c
    ../../../../nrf5_sdk/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../nrf5_sdk/components/libraries/timer/: app_timer.c
    ../../../../nrf5_sdk/components/libraries/trace/: app_trace.c
    ../../../../nrf5_sdk/components/libraries/fstorage/: fstorage.c
    ../../../../nrf5_sdk/components/libraries/uart/: retarget.c
    ../../../../nrf5_sdk/components/libraries/sensorsim/: sensorsim.c
  group nRF_Segger_RTT
    ../../../../nrf5_sdk/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../nrf5_sdk/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Unit Tests
    ../../../unit_tests/: all_tests.c test_bmd_accel.c
target bmd-300-demo-shield-debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
target bmd-300-demo-shield-test (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_GPIO_AS_PINRESET USE_INTERNAL_RC ENABLE_UNITY
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
target flash_s132_nrf52_2.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_template_s132_pca10040;..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
